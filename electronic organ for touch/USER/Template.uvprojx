# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 地板分板V2 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\KEY;..\HARDWARE\CAN;..\CODE;..\USER;..\SYSTEM\wwdg;..\SYSTEM\tim;..\HARDWARE\LED;..\CODE;..\HARDWARE\ADC;..\HARDWARE\EEPROM;..\HARDWARE\XT1506S;..\HARDWARE\24l01;..\SYSTEM\cJSON
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c canType.c gameTask.c gameTask.h main.h 24l01Buf.c 24l01Buf.h gamePackDeal.c gamePackDeal.h
  group CORE
    ../CORE/: startup_stm32f10x_hd.s core_cm3.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/wwdg/: wwdg.c
    ../SYSTEM/tim/: tim.c
    ../SYSTEM/cJSON/: cJSON.c cJSON.h cJsonDataDeal.c cJsonDataDeal.h wifiusart.c wifiusart.h malloc.c malloc.h
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/EEPROM/: eeprom.c
    ../HARDWARE/24l01/: 24l01.c 24l01.h spi.c spi.h
    ../HARDWARE/XT1506S/: XT1506S.C
  group CODE
    ../CODE/: CRC.c RAND_NUM.c
